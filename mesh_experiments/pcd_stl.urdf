Commit message: new files added

File: mesh_experiments/pcd_stl.urdf (robot description, URDF)
Before this commit: robot pcd_stl.urdf, 1 links, 0 joints
Links:
- link pcd_stl_trial: geometry collision box size=.1 .1 .1; visual mesh filename=mesh_hull.STL scale=1 1 1
